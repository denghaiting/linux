# Keil uVision project stm32f030_iap.uvprojx, settings and files
target stm32f030_iap (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f030_iap
  AfterMake: fromelf.exe --bin -o../Output/stm32f030_iap.bin ../Obj/stm32f030_iap.axf
  AfterMake: cmd.bat
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: ..\SourceCode\App;..\SourceCode\CMSIS;..\SourceCode\FWlib\inc;..\SourceCode\BSP;..\SourceCode\SYS;..\SourceCode\tools
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Programm_use.sct
  group FWlib
    ../SourceCode/FWlib/src/: stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_dma.c stm32f0xx_rcc.c stm32f0xx_iwdg.c
  group CMSIS
    ../SourceCode/CMSIS/: system_stm32f0xx.c
    ../SourceCode/CMSIS/startup/: startup_stm32f030.s
  group BSP
    ../SourceCode/BSP/: usart.c bsp_tim16.c bsp_usart1.c bsp_gpio.c bsp_tim3.c bsp_usart2.c bsp_flash.c
  group App
    ../SourceCode/App/: main.c ymodem.c usart_comm.c user_interface.c
  group SYS
    ../SourceCode/SYS/: isr.c sys.c
  group TOOLS
    ../SourceCode/tools/: event.c fifo.c list.c
